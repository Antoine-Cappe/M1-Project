Title: simul16-dec-2025_13-22-08.cir
Date: Tue Dec 16 13:22:14  2025
Plotname: AC Analysis
Flags: complex
No. Variables: 3
No. Points: 64
Variables:
	0	frequency	frequency grid=3
	1	vdb(671,15)-vdb(15)-66	notype
	2	vp(671,15)-vp(15)	notype
Values:
 0	1.000000000000000e+03,0.000000000000000e+00
	4.843893024816143e+01,0.0
	-5.563192876401424e-03,0.0

 1	1.291549665014884e+03,0.000000000000000e+00
	4.843884045042319e+01,0.0
	-7.185090374182645e-03,0.0

 2	1.668100537200059e+03,0.000000000000000e+00
	4.843869066289949e+01,0.0
	-9.279794378039432e-03,0.0

 3	2.154434690031884e+03,0.000000000000000e+00
	4.843844081374650e+01,0.0
	-1.198508548107532e-02,0.0

 4	2.782559402207125e+03,0.000000000000000e+00
	4.843802407222395e+01,0.0
	-1.547883801012158e-02,0.0

 5	3.593813663804627e+03,0.000000000000000e+00
	4.843732899444456e+01,0.0
	-1.999062148940298e-02,0.0

 6	4.641588833612779e+03,0.000000000000000e+00
	4.843616978232801e+01,0.0
	-2.581658324843948e-02,0.0

 7	5.994842503189410e+03,0.000000000000000e+00
	4.843423678825883e+01,0.0
	-3.333845230758491e-02,0.0

 8	7.742636826811271e+03,0.000000000000000e+00
	4.843101427315244e+01,0.0
	-4.304761621204531e-02,0.0

 9	1.000000000000000e+04,0.000000000000000e+00
	4.842564410935509e+01,0.0
	-5.557521529312307e-02,0.0

 10	1.291549665014884e+04,0.000000000000000e+00
	4.841670088684393e+01,0.0
	-7.172887076502678e-02,0.0

 11	1.668100537200059e+04,0.000000000000000e+00
	4.840182355346107e+01,0.0
	-9.253557758634316e-02,0.0

 12	2.154434690031883e+04,0.000000000000000e+00
	4.837711951949268e+01,0.0
	-1.192875530442248e-01,0.0

 13	2.782559402207124e+04,0.000000000000000e+00
	4.833622087214661e+01,0.0
	-1.535817125030454e-01,0.0

 14	3.593813663804626e+04,0.000000000000000e+00
	4.826884341584031e+01,0.0
	-1.973309900798247e-01,0.0

 15	4.641588833612778e+04,0.000000000000000e+00
	4.815872630033317e+01,0.0
	-2.527030489093467e-01,0.0

 16	5.994842503189408e+04,0.000000000000000e+00
	4.798103427683395e+01,0.0
	-3.219078286055558e-01,0.0

 17	7.742636826811268e+04,0.000000000000000e+00
	4.769990657699378e+01,0.0
	-4.067243254804135e-01,0.0

 18	9.999999999999997e+04,0.000000000000000e+00
	4.726801780084260e+01,0.0
	-5.076863043168517e-01,0.0

 19	1.291549665014884e+05,0.000000000000000e+00
	4.663129062173975e+01,0.0
	-6.230485827961671e-01,0.0

 20	1.668100537200058e+05,0.000000000000000e+00
	4.574114523218485e+01,0.0
	-7.480743746375437e-01,0.0

 21	2.154434690031883e+05,0.000000000000000e+00
	4.457129300240094e+01,0.0
	-8.754699037111086e-01,0.0

 22	2.782559402207124e+05,0.000000000000000e+00
	4.312896964927518e+01,0.0
	-9.972440316674120e-01,0.0

 23	3.593813663804627e+05,0.000000000000000e+00
	4.145169792558782e+01,0.0
	-1.107014375249106e+00,0.0

 24	4.641588833612778e+05,0.000000000000000e+00
	3.959228762622774e+01,0.0
	-1.201319093629661e+00,0.0

 25	5.994842503189410e+05,0.000000000000000e+00
	3.760304787880065e+01,0.0
	-1.279483752894700e+00,0.0

 26	7.742636826811270e+05,0.000000000000000e+00
	3.552673300830976e+01,0.0
	-1.342679900451130e+00,0.0

 27	9.999999999999999e+05,0.000000000000000e+00
	3.339438951693489e+01,0.0
	-1.392944539175764e+00,0.0

 28	1.291549665014884e+06,0.000000000000000e+00
	3.122695370387692e+01,0.0
	-1.432509899061365e+00,0.0

 29	1.668100537200059e+06,0.000000000000000e+00
	2.903790951658307e+01,0.0
	-1.463452598523815e+00,0.0

 30	2.154434690031883e+06,0.000000000000000e+00
	2.683569920741490e+01,0.0
	-1.487556053378907e+00,0.0

 31	2.782559402207124e+06,0.000000000000000e+00
	2.462551817174048e+01,0.0
	-1.506286758172816e+00,0.0

 32	3.593813663804627e+06,0.000000000000000e+00
	2.241053048979364e+01,0.0
	-1.520821140689280e+00,0.0

 33	4.641588833612778e+06,0.000000000000000e+00
	2.019265104540312e+01,0.0
	-1.532089432007067e+00,0.0

 34	5.994842503189409e+06,0.000000000000000e+00
	1.797303433363318e+01,0.0
	-1.540820963130363e+00,0.0

 35	7.742636826811269e+06,0.000000000000000e+00
	1.575237482365651e+01,0.0
	-1.547584673685154e+00,0.0

 36	9.999999999999998e+06,0.000000000000000e+00
	1.353108969248203e+01,0.0
	-1.552823050781602e+00,0.0

 37	1.291549665014884e+07,0.000000000000000e+00
	1.130942933853176e+01,0.0
	-1.556879615888958e+00,0.0

 38	1.668100537200058e+07,0.000000000000000e+00
	9.087543982323666e+00,0.0
	-1.560020772194642e+00,0.0

 39	2.154434690031883e+07,0.000000000000000e+00
	6.865523718527498e+00,0.0
	-1.562452983683573e+00,0.0

 40	2.782559402207124e+07,0.000000000000000e+00
	4.643422571686784e+00,0.0
	-1.564336198831964e+00,0.0

 41	3.593813663804627e+07,0.000000000000000e+00
	2.421272933834629e+00,0.0
	-1.565794301000560e+00,0.0

 42	4.641588833612779e+07,0.000000000000000e+00
	1.990942253970331e-01,0.0
	-1.566923226160963e+00,0.0

 43	5.994842503189410e+07,0.000000000000000e+00
	-2.023101910809686e+00,0.0
	-1.567797260303888e+00,0.0

 44	7.742636826811270e+07,0.000000000000000e+00
	-4.245308494724689e+00,0.0
	-1.568473920808194e+00,0.0

 45	1.000000000000000e+08,0.000000000000000e+00
	-6.467521342052450e+00,0.0
	-1.568997738305355e+00,0.0

 46	1.291549665014884e+08,0.000000000000000e+00
	-8.689737944099740e+00,0.0
	-1.569403185743036e+00,0.0

 47	1.668100537200059e+08,0.000000000000000e+00
	-1.091195679712595e+01,0.0
	-1.569716946401000e+00,0.0

 48	2.154434690031884e+08,0.000000000000000e+00
	-1.313417699959009e+01,0.0
	-1.569959669652362e+00,0.0

 49	2.782559402207125e+08,0.000000000000000e+00
	-1.535639801098009e+01,0.0
	-1.570147329803314e+00,0.0

 50	3.593813663804628e+08,0.000000000000000e+00
	-1.757861950728794e+01,0.0
	-1.570292277339278e+00,0.0

 51	4.641588833612779e+08,0.000000000000000e+00
	-1.980084129429014e+01,0.0
	-1.570404051716219e+00,0.0

 52	5.994842503189411e+08,0.000000000000000e+00
	-2.202306325546138e+01,0.0
	-1.570490009167716e+00,0.0

 53	7.742636826811272e+08,0.000000000000000e+00
	-2.424528532109152e+01,0.0
	-1.570555806835677e+00,0.0

 54	1.000000000000000e+09,0.000000000000000e+00
	-2.646750744921916e+01,0.0
	-1.570605775082240e+00,0.0

 55	1.291549665014884e+09,0.000000000000000e+00
	-2.868972961461245e+01,0.0
	-1.570643202483755e+00,0.0

 56	1.668100537200059e+09,0.000000000000000e+00
	-3.091195180214835e+01,0.0
	-1.570670552262239e+00,0.0

 57	2.154434690031884e+09,0.000000000000000e+00
	-3.313417400249909e+01,0.0
	-1.570689624397907e+00,0.0

 58	2.782559402207125e+09,0.000000000000000e+00
	-3.535639620975096e+01,0.0
	-1.570701674091738e+00,0.0

 59	3.593813663804628e+09,0.000000000000000e+00
	-3.757861842007873e+01,0.0
	-1.570707494374369e+00,0.0

 60	4.641588833612780e+09,0.000000000000000e+00
	-3.980084063004178e+01,0.0
	-1.570707468298080e+00,0.0

 61	5.994842503189411e+09,0.000000000000000e+00
	-4.202306283660027e+01,0.0
	-1.570701594146730e+00,0.0

 62	7.742636826811272e+09,0.000000000000000e+00
	-4.424528503535777e+01,0.0
	-1.570689485322837e+00,0.0

 63	1.000000000000000e+10,0.000000000000000e+00
	-4.646750722013163e+01,0.0
	-1.570670344904340e+00,0.0

