Title: simul15-jul-2025_11-25-45.cir
Date: Tue Jul 15 11:25:50  2025
Plotname: AC Analysis
Flags: complex
No. Variables: 3
No. Points: 64
Variables:
	0	frequency	frequency grid=3
	1	vdb(692,30)-vdb(30)-66	notype
	2	vp(692,30)-vp(30)	notype
Values:
 0	1.000000000000000e+03,0.000000000000000e+00
	1.678040543901688e+02,0.0
	-5.563192874636280e-03,0.0

 1	1.291549665014884e+03,0.000000000000000e+00
	1.678039645924305e+02,0.0
	-7.185090371902840e-03,0.0

 2	1.668100537200059e+03,0.000000000000000e+00
	1.678038148049068e+02,0.0
	-9.279794375094963e-03,0.0

 3	2.154434690031884e+03,0.000000000000000e+00
	1.678035649557538e+02,0.0
	-1.198508547727243e-02,0.0

 4	2.782559402207125e+03,0.000000000000000e+00
	1.678031482142313e+02,0.0
	-1.547883800521000e-02,0.0

 5	3.593813663804627e+03,0.000000000000000e+00
	1.678024531364519e+02,0.0
	-1.999062148305936e-02,0.0

 6	4.641588833612779e+03,0.000000000000000e+00
	1.678012939243354e+02,0.0
	-2.581658324024618e-02,0.0

 7	5.994842503189410e+03,0.000000000000000e+00
	1.677993609302662e+02,0.0
	-3.333845229700307e-02,0.0

 8	7.742636826811271e+03,0.000000000000000e+00
	1.677961384151598e+02,0.0
	-4.304761619837830e-02,0.0

 9	1.000000000000000e+04,0.000000000000000e+00
	1.677907682513625e+02,0.0
	-5.557521527547175e-02,0.0

 10	1.291549665014884e+04,0.000000000000000e+00
	1.677818250288513e+02,0.0
	-7.172887074222908e-02,0.0

 11	1.668100537200059e+04,0.000000000000000e+00
	1.677669476954684e+02,0.0
	-9.253557755689812e-02,0.0

 12	2.154434690031883e+04,0.000000000000000e+00
	1.677422436615001e+02,0.0
	-1.192875530061961e-01,0.0

 13	2.782559402207124e+04,0.000000000000000e+00
	1.677013450141539e+02,0.0
	-1.535817124539277e-01,0.0

 14	3.593813663804626e+04,0.000000000000000e+00
	1.676339675578477e+02,0.0
	-1.973309900163881e-01,0.0

 15	4.641588833612778e+04,0.000000000000000e+00
	1.675238504423405e+02,0.0
	-2.527030488274132e-01,0.0

 16	5.994842503189408e+04,0.000000000000000e+00
	1.673461584188414e+02,0.0
	-3.219078284997364e-01,0.0

 17	7.742636826811268e+04,0.000000000000000e+00
	1.670650307190012e+02,0.0
	-4.067243253437427e-01,0.0

 18	9.999999999999997e+04,0.000000000000000e+00
	1.666331419428506e+02,0.0
	-5.076863041403343e-01,0.0

 19	1.291549665014884e+05,0.000000000000000e+00
	1.659964147637479e+02,0.0
	-6.230485825681877e-01,0.0

 20	1.668100537200058e+05,0.000000000000000e+00
	1.651062693741932e+02,0.0
	-7.480743743430970e-01,0.0

 21	2.154434690031883e+05,0.000000000000000e+00
	1.639364171444096e+02,0.0
	-8.754699033308153e-01,0.0

 22	2.782559402207124e+05,0.000000000000000e+00
	1.624940937912844e+02,0.0
	-9.972440311762418e-01,0.0

 23	3.593813663804627e+05,0.000000000000000e+00
	1.608168220675974e+02,0.0
	-1.107014374614739e+00,0.0

 24	4.641588833612778e+05,0.000000000000000e+00
	1.589574117682429e+02,0.0
	-1.201319092810344e+00,0.0

 25	5.994842503189410e+05,0.000000000000000e+00
	1.569681720208158e+02,0.0
	-1.279483751836510e+00,0.0

 26	7.742636826811270e+05,0.000000000000000e+00
	1.548918571503239e+02,0.0
	-1.342679899084426e+00,0.0

 27	9.999999999999999e+05,0.000000000000000e+00
	1.527595136589464e+02,0.0
	-1.392944537410598e+00,0.0

 28	1.291549665014884e+06,0.000000000000000e+00
	1.505920778458778e+02,0.0
	-1.432509896781565e+00,0.0

 29	1.668100537200059e+06,0.000000000000000e+00
	1.484030336585944e+02,0.0
	-1.463452595579340e+00,0.0

 30	2.154434690031883e+06,0.000000000000000e+00
	1.462008233494204e+02,0.0
	-1.487556049575972e+00,0.0

 31	2.782559402207124e+06,0.000000000000000e+00
	1.439906423137556e+02,0.0
	-1.506286753261136e+00,0.0

 32	3.593813663804627e+06,0.000000000000000e+00
	1.417756546317979e+02,0.0
	-1.520821134345602e+00,0.0

 33	4.641588833612778e+06,0.000000000000000e+00
	1.395577751874239e+02,0.0
	-1.532089423813892e+00,0.0

 34	5.994842503189409e+06,0.000000000000000e+00
	1.373381584756416e+02,0.0
	-1.540820952548471e+00,0.0

 35	7.742636826811269e+06,0.000000000000000e+00
	1.351174989656485e+02,0.0
	-1.547584660018114e+00,0.0

 36	9.999999999999998e+06,0.000000000000000e+00
	1.328962138344552e+02,0.0
	-1.552823033129941e+00,0.0

 37	1.291549665014884e+07,0.000000000000000e+00
	1.306745534805021e+02,0.0
	-1.556879593090961e+00,0.0

 38	1.668100537200058e+07,0.000000000000000e+00
	1.284526681243121e+02,0.0
	-1.560020742749896e+00,0.0

 39	2.154434690031883e+07,0.000000000000000e+00
	1.262306478604989e+02,0.0
	-1.562452945654221e+00,0.0

 40	2.782559402207124e+07,0.000000000000000e+00
	1.240085467136651e+02,0.0
	-1.564336149715168e+00,0.0

 41	3.593813663804627e+07,0.000000000000000e+00
	1.217863970758500e+02,0.0
	-1.565794237563778e+00,0.0

 42	4.641588833612779e+07,0.000000000000000e+00
	1.195642183674188e+02,0.0
	-1.566923144229208e+00,0.0

 43	5.994842503189410e+07,0.000000000000000e+00
	1.173420222312392e+02,0.0
	-1.567797154484957e+00,0.0

 44	7.742636826811270e+07,0.000000000000000e+00
	1.151198156472655e+02,0.0
	-1.568473784137790e+00,0.0

 45	1.000000000000000e+08,0.000000000000000e+00
	1.128976027999567e+02,0.0
	-1.568997561788740e+00,0.0

 46	1.291549665014884e+08,0.000000000000000e+00
	1.106753861978619e+02,0.0
	-1.569402957763061e+00,0.0

 47	1.668100537200059e+08,0.000000000000000e+00
	1.084531673448290e+02,0.0
	-1.569716651953541e+00,0.0

 48	2.154434690031884e+08,0.000000000000000e+00
	1.062309471423972e+02,0.0
	-1.569959289358844e+00,0.0

 49	2.782559402207125e+08,0.000000000000000e+00
	1.040087261310299e+02,0.0
	-1.570146838635349e+00,0.0

 50	3.593813663804628e+08,0.000000000000000e+00
	1.017865046347331e+02,0.0
	-1.570291642971457e+00,0.0

 51	4.641588833612779e+08,0.000000000000000e+00
	9.956428284775325e+01,0.0
	-1.570403232398672e+00,0.0

 52	5.994842503189411e+08,0.000000000000000e+00
	9.734206088655424e+01,0.0
	-1.570488950978412e+00,0.0

 53	7.742636826811272e+08,0.000000000000000e+00
	9.511983882098195e+01,0.0
	-1.570554440131637e+00,0.0

 54	1.000000000000000e+09,0.000000000000000e+00
	9.289761669295362e+01,0.0
	-1.570604009916095e+00,0.0

 55	1.291549665014884e+09,0.000000000000000e+00
	9.067539452767409e+01,0.0
	-1.570640922684012e+00,0.0

 56	1.668100537200059e+09,0.000000000000000e+00
	8.845317234038035e+01,0.0
	-1.570667607787644e+00,0.0

 57	2.154434690031884e+09,0.000000000000000e+00
	8.623095014041866e+01,0.0
	-1.570685821462733e+00,0.0

 58	2.782559402207125e+09,0.000000000000000e+00
	8.400872793374566e+01,0.0
	-1.570696762412089e+00,0.0

 59	3.593813663804628e+09,0.000000000000000e+00
	8.178650572452190e+01,0.0
	-1.570701150696172e+00,0.0

 60	4.641588833612780e+09,0.000000000000000e+00
	7.956428351622588e+01,0.0
	-1.570699275122644e+00,0.0

 61	5.994842503189411e+09,0.000000000000000e+00
	7.734206131258387e+01,0.0
	-1.570691012253769e+00,0.0

 62	7.742636826811272e+09,0.000000000000000e+00
	7.511983911856760e+01,0.0
	-1.570675818282590e+00,0.0

 63	1.000000000000000e+10,0.000000000000000e+00
	7.289761694172478e+01,0.0
	-1.570652693243227e+00,0.0

