Title: simul16-dec-2025_13-23-57.cir
Date: Tue Dec 16 13:24:08  2025
Plotname: AC Analysis
Flags: complex
No. Variables: 3
No. Points: 64
Variables:
	0	frequency	frequency grid=3
	1	vdb(85,1246)-vdb(1246)-66	notype
	2	vp(85,1246)-vp(1246)	notype
Values:
 0	1.000000000000000e+03,0.000000000000000e+00
	4.762372376915461e+01,0.0
	-5.563192870437187e-03,0.0

 1	1.291549665014884e+03,0.000000000000000e+00
	4.762363397141631e+01,0.0
	-7.185090366479478e-03,0.0

 2	1.668100537200059e+03,0.000000000000000e+00
	4.762348418389259e+01,0.0
	-9.279794368090472e-03,0.0

 3	2.154434690031884e+03,0.000000000000000e+00
	4.762323433473962e+01,0.0
	-1.198508546822569e-02,0.0

 4	2.782559402207125e+03,0.000000000000000e+00
	4.762281759321716e+01,0.0
	-1.547883799352569e-02,0.0

 5	3.593813663804627e+03,0.000000000000000e+00
	4.762212251543771e+01,0.0
	-1.999062146796849e-02,0.0

 6	4.641588833612779e+03,0.000000000000000e+00
	4.762096330332119e+01,0.0
	-2.581658322075607e-02,0.0

 7	5.994842503189410e+03,0.000000000000000e+00
	4.761903030925203e+01,0.0
	-3.333845227183018e-02,0.0

 8	7.742636826811271e+03,0.000000000000000e+00
	4.761580779414560e+01,0.0
	-4.304761616586625e-02,0.0

 9	1.000000000000000e+04,0.000000000000000e+00
	4.761043763034824e+01,0.0
	-5.557521523348084e-02,0.0

 10	1.291549665014884e+04,0.000000000000000e+00
	4.760149440783709e+01,0.0
	-7.172887068799599e-02,0.0

 11	1.668100537200059e+04,0.000000000000000e+00
	4.758661707445424e+01,0.0
	-9.253557748685289e-02,0.0

 12	2.154434690031883e+04,0.000000000000000e+00
	4.756191304048585e+01,0.0
	-1.192875529157291e-01,0.0

 13	2.782559402207124e+04,0.000000000000000e+00
	4.752101439313972e+01,0.0
	-1.535817123370869e-01,0.0

 14	3.593813663804626e+04,0.000000000000000e+00
	4.745363693683339e+01,0.0
	-1.973309898654808e-01,0.0

 15	4.641588833612778e+04,0.000000000000000e+00
	4.734351982132625e+01,0.0
	-2.527030486325111e-01,0.0

 16	5.994842503189408e+04,0.000000000000000e+00
	4.716582779782692e+01,0.0
	-3.219078282480069e-01,0.0

 17	7.742636826811268e+04,0.000000000000000e+00
	4.688470009798658e+01,0.0
	-4.067243250186223e-01,0.0

 18	9.999999999999997e+04,0.000000000000000e+00
	4.645281132183595e+01,0.0
	-5.076863037204276e-01,0.0

 19	1.291549665014884e+05,0.000000000000000e+00
	4.581608414273305e+01,0.0
	-6.230485820258538e-01,0.0

 20	1.668100537200058e+05,0.000000000000000e+00
	4.492593875317576e+01,0.0
	-7.480743736426448e-01,0.0

 21	2.154434690031883e+05,0.000000000000000e+00
	4.375608652339116e+01,0.0
	-8.754699024261454e-01,0.0

 22	2.782559402207124e+05,0.000000000000000e+00
	4.231376317026506e+01,0.0
	-9.972440300078179e-01,0.0

 23	3.593813663804627e+05,0.000000000000000e+00
	4.063649144657809e+01,0.0
	-1.107014373105661e+00,0.0

 24	4.641588833612778e+05,0.000000000000000e+00
	3.877708114722392e+01,0.0
	-1.201319090861296e+00,0.0

 25	5.994842503189410e+05,0.000000000000000e+00
	3.678784139979578e+01,0.0
	-1.279483749319220e+00,0.0

 26	7.742636826811270e+05,0.000000000000000e+00
	3.471152652930235e+01,0.0
	-1.342679895833221e+00,0.0

 27	9.999999999999999e+05,0.000000000000000e+00
	3.257918303792660e+01,0.0
	-1.392944533211508e+00,0.0

 28	1.291549665014884e+06,0.000000000000000e+00
	3.041174722486754e+01,0.0
	-1.432509891358231e+00,0.0

 29	1.668100537200059e+06,0.000000000000000e+00
	2.822270303757956e+01,0.0
	-1.463452588574836e+00,0.0

 30	2.154434690031883e+06,0.000000000000000e+00
	2.602049272839162e+01,0.0
	-1.487556040529307e+00,0.0

 31	2.782559402207124e+06,0.000000000000000e+00
	2.381031169272923e+01,0.0
	-1.506286741576920e+00,0.0

 32	3.593813663804627e+06,0.000000000000000e+00
	2.159532401076389e+01,0.0
	-1.520821119254856e+00,0.0

 33	4.641588833612778e+06,0.000000000000000e+00
	1.937744456640641e+01,0.0
	-1.532089404323444e+00,0.0

 34	5.994842503189409e+06,0.000000000000000e+00
	1.715782785461700e+01,0.0
	-1.540820927375590e+00,0.0

 35	7.742636826811269e+06,0.000000000000000e+00
	1.493716834464534e+01,0.0
	-1.547584627506088e+00,0.0

 36	9.999999999999998e+06,0.000000000000000e+00
	1.271588321344740e+01,0.0
	-1.552822991139044e+00,0.0

 37	1.291549665014884e+07,0.000000000000000e+00
	1.049422285950030e+01,0.0
	-1.556879538857632e+00,0.0

 38	1.668100537200058e+07,0.000000000000000e+00
	8.272337503301372e+00,0.0
	-1.560020672704859e+00,0.0

 39	2.154434690031883e+07,0.000000000000000e+00
	6.050317239508388e+00,0.0
	-1.562452855187578e+00,0.0

 40	2.782559402207124e+07,0.000000000000000e+00
	3.828216092662558e+00,0.0
	-1.564336032873004e+00,0.0

 41	3.593813663804627e+07,0.000000000000000e+00
	1.606066454882907e+00,0.0
	-1.565794086656320e+00,0.0

 42	4.641588833612779e+07,0.000000000000000e+00
	-6.161122535301899e-01,0.0
	-1.566922949324732e+00,0.0

 43	5.994842503189410e+07,0.000000000000000e+00
	-2.838308389700600e+00,0.0
	-1.567796902756147e+00,0.0

 44	7.742636826811270e+07,0.000000000000000e+00
	-5.060514973728722e+00,0.0
	-1.568473459017529e+00,0.0

 45	1.000000000000000e+08,0.000000000000000e+00
	-7.282727820985563e+00,0.0
	-1.568997141879776e+00,0.0

 46	1.291549665014884e+08,0.000000000000000e+00
	-9.504944423029741e+00,0.0
	-1.569402415429780e+00,0.0

 47	1.668100537200059e+08,0.000000000000000e+00
	-1.172716327614409e+01,0.0
	-1.569715951503172e+00,0.0

 48	2.154434690031884e+08,0.000000000000000e+00
	-1.394938347854384e+01,0.0
	-1.569958384692406e+00,0.0

 49	2.782559402207125e+08,0.000000000000000e+00
	-1.617160448981583e+01,0.0
	-1.570145670213713e+00,0.0

 50	3.593813663804628e+08,0.000000000000000e+00
	-1.839382598609736e+01,0.0
	-1.570290133896885e+00,0.0

 51	4.641588833612779e+08,0.000000000000000e+00
	-2.061604777307450e+01,0.0
	-1.570401283353914e+00,0.0

 52	5.994842503189411e+08,0.000000000000000e+00
	-2.283826973411851e+01,0.0
	-1.570486433690308e+00,0.0

 53	7.742636826811272e+08,0.000000000000000e+00
	-2.506049179950639e+01,0.0
	-1.570551188929030e+00,0.0

 54	1.000000000000000e+09,0.000000000000000e+00
	-2.728271392724842e+01,0.0
	-1.570599810826458e+00,0.0

 55	1.291549665014884e+09,0.000000000000000e+00
	-2.950493609202425e+01,0.0
	-1.570635499351199e+00,0.0

 56	1.668100537200059e+09,0.000000000000000e+00
	-3.172715827842598e+01,0.0
	-1.570660603283971e+00,0.0

 57	2.154434690031884e+09,0.000000000000000e+00
	-3.394938047696898e+01,0.0
	-1.570676774798367e+00,0.0

 58	2.782559402207125e+09,0.000000000000000e+00
	-3.617160268131553e+01,0.0
	-1.570685078195774e+00,0.0

 59	3.593813663804628e+09,0.000000000000000e+00
	-3.839382488652920e+01,0.0
	-1.570686059950538e+00,0.0

 60	4.641588833612780e+09,0.000000000000000e+00
	-4.061604708812632e+01,0.0
	-1.570679784675250e+00,0.0

 61	5.994842503189411e+09,0.000000000000000e+00
	-4.283826928069792e+01,0.0
	-1.570665839373128e+00,0.0

 62	7.742636826811272e+09,0.000000000000000e+00
	-4.506049145630812e+01,0.0
	-1.570643306257374e+00,0.0

 63	1.000000000000000e+10,0.000000000000000e+00
	-4.728271360236360e+01,0.0
	-1.570610702348693e+00,0.0

