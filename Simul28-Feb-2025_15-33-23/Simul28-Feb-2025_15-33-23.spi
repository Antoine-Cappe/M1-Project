Title: simul28-feb-2025_15-33-23.cir
Date: Fri Feb 28 15:33:28  2025
Plotname: AC Analysis
Flags: complex
No. Variables: 3
No. Points: 46
Variables:
	0	frequency	frequency grid=3
	1	vdb(30,616)-vdb(616)-66	notype
	2	vp(30,616)-vp(616)	notype
Values:
 0	1.000000000000000e+03,0.000000000000000e+00
	8.161894275048945e+01,0.0
	-4.450600223902211e-07,0.0

 1	1.291549665014884e+03,0.000000000000000e+00
	8.161894275048888e+01,0.0
	-5.748171228295800e-07,0.0

 2	1.668100537200059e+03,0.000000000000000e+00
	8.161894275048789e+01,0.0
	-7.424048624353249e-07,0.0

 3	2.154434690031884e+03,0.000000000000000e+00
	8.161894275048633e+01,0.0
	-9.588527513836251e-07,0.0

 4	2.782559402207125e+03,0.000000000000000e+00
	8.161894275048363e+01,0.0
	-1.238405949847914e-06,0.0

 5	3.593813663804627e+03,0.000000000000000e+00
	8.161894275047911e+01,0.0
	-1.599462789677952e-06,0.0

 6	4.641588833612779e+03,0.000000000000000e+00
	8.161894275047177e+01,0.0
	-2.065785630211122e-06,0.0

 7	5.994842503189410e+03,0.000000000000000e+00
	8.161894275045935e+01,0.0
	-2.668064738689283e-06,0.0

 8	7.742636826811271e+03,0.000000000000000e+00
	8.161894275043875e+01,0.0
	-3.445938119486508e-06,0.0

 9	1.000000000000000e+04,0.000000000000000e+00
	8.161894275040422e+01,0.0
	-4.450600223873120e-06,0.0

 10	1.291549665014884e+04,0.000000000000000e+00
	8.161894275034680e+01,0.0
	-5.748171228233236e-06,0.0

 11	1.668100537200059e+04,0.000000000000000e+00
	8.161894275025094e+01,0.0
	-7.424048624218237e-06,0.0

 12	2.154434690031883e+04,0.000000000000000e+00
	8.161894275009098e+01,0.0
	-9.588527513545536e-06,0.0

 13	2.782559402207124e+04,0.000000000000000e+00
	8.161894274982433e+01,0.0
	-1.238405949785206e-05,0.0

 14	3.593813663804626e+04,0.000000000000000e+00
	8.161894274937924e+01,0.0
	-1.599462789542857e-05,0.0

 15	4.641588833612778e+04,0.000000000000000e+00
	8.161894274863693e+01,0.0
	-2.065785629920219e-05,0.0

 16	5.994842503189408e+04,0.000000000000000e+00
	8.161894274739871e+01,0.0
	-2.668064738062420e-05,0.0

 17	7.742636826811268e+04,0.000000000000000e+00
	8.161894274533330e+01,0.0
	-3.445938118136276e-05,0.0

 18	9.999999999999997e+04,0.000000000000000e+00
	8.161894274188785e+01,0.0
	-4.450600220963975e-05,0.0

 19	1.291549665014884e+05,0.000000000000000e+00
	8.161894273614053e+01,0.0
	-5.748171221965506e-05,0.0

 20	1.668100537200058e+05,0.000000000000000e+00
	8.161894272655351e+01,0.0
	-7.424048610715015e-05,0.0

 21	2.154434690031883e+05,0.000000000000000e+00
	8.161894271056136e+01,0.0
	-9.588527484453757e-05,0.0

 22	2.782559402207124e+05,0.000000000000000e+00
	8.161894268388474e+01,0.0
	-1.238405943517593e-04,0.0

 23	3.593813663804627e+05,0.000000000000000e+00
	8.161894263938552e+01,0.0
	-1.599462776039714e-04,0.0

 24	4.641588833612778e+05,0.000000000000000e+00
	8.161894256515637e+01,0.0
	-2.065785600828394e-04,0.0

 25	5.994842503189410e+05,0.000000000000000e+00
	8.161894244133470e+01,0.0
	-2.668064675386184e-04,0.0

 26	7.742636826811270e+05,0.000000000000000e+00
	8.161894223478777e+01,0.0
	-3.445937983104386e-04,0.0

 27	9.999999999999999e+05,0.000000000000000e+00
	8.161894189024673e+01,0.0
	-4.450599930046560e-04,0.0

 28	1.291549665014884e+06,0.000000000000000e+00
	8.161894131551759e+01,0.0
	-5.748170595203006e-04,0.0

 29	1.668100537200059e+06,0.000000000000000e+00
	8.161894035681183e+01,0.0
	-7.424047260396301e-04,0.0

 30	2.154434690031883e+06,0.000000000000000e+00
	8.161893875759478e+01,0.0
	-9.588524575281400e-04,0.0

 31	2.782559402207124e+06,0.000000000000000e+00
	8.161893608994112e+01,0.0
	-1.238405316755608e-03,0.0

 32	3.593813663804627e+06,0.000000000000000e+00
	8.161893164003030e+01,0.0
	-1.599461425722835e-03,0.0

 33	4.641588833612778e+06,0.000000000000000e+00
	8.161892421714194e+01,0.0
	-2.065782691661995e-03,0.0

 34	5.994842503189409e+06,0.000000000000000e+00
	8.161891183504602e+01,0.0
	-2.668058407787834e-03,0.0

 35	7.742636826811269e+06,0.000000000000000e+00
	8.161889118054373e+01,0.0
	-3.445924480011992e-03,0.0

 36	9.999999999999998e+06,0.000000000000000e+00
	8.161885672697591e+01,0.0
	-4.450570838655955e-03,0.0

 37	1.291549665014884e+07,0.000000000000000e+00
	8.161879925556923e+01,0.0
	-5.748107920204362e-03,0.0

 38	1.668100537200058e+07,0.000000000000000e+00
	8.161870338917731e+01,0.0
	-7.423912233011378e-03,0.0

 39	2.154434690031883e+07,0.000000000000000e+00
	8.161854347910634e+01,0.0
	-9.588233674089805e-03,0.0

 40	2.782559402207124e+07,0.000000000000000e+00
	8.161827674613315e+01,0.0
	-1.238342646326416e-02,0.0

 41	3.593813663804627e+07,0.000000000000000e+00
	8.161783184516955e+01,0.0
	-1.599326414758141e-02,0.0

 42	4.641588833612779e+07,0.000000000000000e+00
	8.161708980704125e+01,0.0
	-2.065491849473714e-02,0.0

 43	5.994842503189410e+07,0.000000000000000e+00
	8.161585229490990e+01,0.0
	-2.667431915490014e-02,0.0

 44	7.742636826811270e+07,0.000000000000000e+00
	8.161378878464535e+01,0.0
	-3.444575131918830e-02,0.0

 45	1.000000000000000e+08,0.000000000000000e+00
	8.161034882240955e+01,0.0
	-4.447665151773501e-02,0.0

